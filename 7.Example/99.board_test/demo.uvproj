# Keil uVision project demo.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 app.c app.h lib_ired.c lib_key.c lib_key.h lib_uart.c lib_uart.h lib_at24c02.c lib_at24c02.h lib_i2c.c lib_i2c.h lib_timer.c lib_timer.h lib_ired.h
