# Keil uVision project demo.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 app.c lib_ds1302.c lib_ds1302.h lib_lcd1602.c lib_lcd1602.h
