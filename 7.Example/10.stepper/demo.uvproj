# Keil uVision project demo.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 app.c lib_28BYJ48.c lib_28BYJ48.h
